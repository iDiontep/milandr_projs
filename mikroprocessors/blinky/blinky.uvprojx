# Keil uVision project blinky.uvprojx, settings and files
target MDR32F9Q2I (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=2 OneElfS=1 v6LangP=3 wLevel=3
  c include: .\hardware_drivers;.\Core;.\Logic
  asm include: ..\Blinky;..\common;..\MDR1211_lcd1602_i2c
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group hardware_drivers
    ./hardware_drivers/Src/: leds.c hardware_drivers.c button.c seg7_display.c keyboard_driver.c
    ./hardware_drivers/Inc/: leds.h hardware_drivers.h button.h seg7_display.h keyboard_driver.h
  group Logic
    ./Logic/Src/: App.c
    ./Logic/Inc/: App.h
  group Core
    ./Core/Src/: main.c
    ./Core/Inc/: main.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.1.0i, Drivers:PORT 2.0.3i, Drivers:RST_CLK 2.0.3i, Drivers:TIMER 2.1.0i
