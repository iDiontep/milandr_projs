# Keil uVision project sev7.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sev7 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c sevseg.c sevseg.h keyboard.c keyboard.h main.h GPIO_Union.c GPIO_Union.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.1.0i
